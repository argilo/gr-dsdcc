options:
  parameters:
    generate_options: qt_gui
    id: rtlsdr_rx
    output_language: python
    title: DSDcc receiver
  states: {}

blocks:
- name: decimation_1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decimation_2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dsd_in_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: dsd_out_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Frequency
    maxFreqHz: 1000e6
    minFreqHz: 30e6
    value: 441.000e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 1944 * 4
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: decimation_2 * dsd_in_rate
  states: {}
- name: low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: if_rate * 0.4
    gain: '1.0'
    samp_rate: samp_rate
    width: if_rate * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: decimation_1 * decimation_2 * dsd_in_rate
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    label: Squelch threshold
    start: '-50'
    step: '1'
    stop: '0'
    value: '-25'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: dsd_in_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: dsd_out_rate
  states: {}
- name: dsdcc_dsdcc_block_0
  id: dsdcc_dsdcc_block
  parameters:
    mode: dsdcc.DSDDecodeAuto
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: decimation_1
    samp_rate: samp_rate
    taps: low_pass_taps
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: decimation_2
    gain: '1'
    samp_rate: if_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: if_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.01'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(dsd_in_rate * 0.060)
    srate: dsd_in_rate
    type: float
    update_time: '0.01'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: freq - offset
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', dsdcc_dsdcc_block_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [dsdcc_dsdcc_block_0, '0', audio_sink_0, '0']
- [dsdcc_dsdcc_block_0, '1', audio_sink_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
